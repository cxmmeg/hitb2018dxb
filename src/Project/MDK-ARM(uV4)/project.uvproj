# Keil uVision project project.uvproj, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\Libraries\CMSIS\Include;..\..\User\bsp;..\..\User\bsp\inc;..\..\User\app\inc;..\..\User\fonts;..\..\User\images;..\..\User\uIP\uip;..\..\User\uIP\http;..\..\User\uIP\dm9000;..\..\User\FatFS\src;..\..\User\usb_mass;..\..\User\CH376\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../../User/app/src/: main.cpp
  group BSP
    ../../User/bsp/src/: bsp_timer.c bsp_key.c bsp_uart_fifo.c bsp_spi_bus.c bsp_tft.c bsp_font.c bsp_user_lib.c bsp_tim_pwm.c bsp_cpu_flash.c bsp_lora.c bsp_rgbled.c bsp_hitb_dxb.c bsp_menu.cpp LCDMenuLib2_menu.cpp LCDMenuLib2.cpp bsp_gfx.c bsp_qrcode.c bsp_snake.c
    ../../User/bsp/: bsp.h bsp.c stm32f10x_it.c stm32f10x_assert.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_spi.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
target CpuRAM (ARM-ADS)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: output +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,VECT_TAB_SRAM
  c misc: --diag_suppress=870
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
